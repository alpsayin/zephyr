## boards/qemu/microblaze/board.yml
```yaml
board:
  name: qemu_microblaze
  full_name: QEMU Emulation for Microblaze
  vendor: qemu
  socs:
  - name: microblaze_demo
```
